# Keil uVision project 25E.uvprojx, settings and files
target Target 1 (6110000::V6.11::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 25E
  BeforeMake: "D:\ti\sysconfig\sysconfig_cli.bat" --product "D:\ti\mspm0\mspm0_sdk_2_06_00_05\.metadata\product.json" --compiler keil --device MSPM0G3507 --package "LQFP-64(PM)" --script "D:\keil_projects\25E\empty.syscfg" --output "D:\keil_projects\25E\"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3505__
  c include: .\hardware\Grayscale_Sensor;.\hardware\MPU6050;.\hardware\OLED;.\library;..\25E;D:\ti\mspm0\mspm0_sdk_2_06_00_05\source;D:\ti\mspm0\mspm0_sdk_2_06_00_05\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\library\mspm0g3507.sct
  link misc: --library_path D:\keil_projects\25E\library\driverlib.a
--library driverlib
  group hardware
    ./hardware/OLED/: OLED.c OLED_DATA.c
    ./hardware/MPU6050/: MPU6050.c
    ./hardware/Grayscale_Sensor/: grayscale_sensor.c
    ./: Interrupt.c main.c
  group main
    ./: main.c
  group sysconfig
    ./library/: empty.syscfg
    ./: ti_msp_dl_config.c ti_msp_dl_config.h
  group delay
    ./library/: Delay.c Delay.h
  group control
    ./: control.c control.h
  group startup
    ./library/: startup_mspm0g350x_uvision.s
  group Interrupt
    ./: Interrupt.c Interrupt.h
